/**
 * @file main.c
 * @brief Пример: четыре диода с разными частотами, скважность 50 %.
 *
 * =====================================================================
 *  ЗАДАЧА
 * =====================================================================
 *
 *   LED0 (PC4) — одна вспышка раз в 4 с
 *   LED1 (PC5) — одна вспышка раз в 2 с
 *   LED2 (PC6) — одна вспышка раз в 1 с
 *   LED3 (PC7) — две вспышки в секунду
 *
 *   Скважность у всех 50 %: половину периода горит, половину гаснет.
 *
 * =====================================================================
 *  КАК ЭТО РАБОТАЕТ
 * =====================================================================
 *
 * У каждого канала свой конечный автомат, поэтому частоты не связаны
 * между собой: это буквально четыре независимых счётчика по 100 мс/1 с/
 * 2 с/4 с. Период задаётся в ТИКАХ, а не в миллисекундах, поэтому
 * накопления ошибки нет — каждый цикл начинается с нового отсчёта.
 *
 * Тик выбирает хост. Здесь он равен 1 мс, то есть периоды — это
 * 4000 / 2000 / 1000 / 500 тиков, а скважность 50 % — половина периода
 * на каждую фазу. Длинные паузы (3 секунды у LED0) не требуют ничего:
 * led_advance() проматывает тики без переходов за O(1) на тик, поэтому
 * цикл из 4000 тиков стоит столько же, сколько один.
 *
 * Для «спящего» МК вместо Delay_Ms() программируется аппаратный таймер
 * пробуждения на led_ticks_until_next() тиков — этот пример на delays
 * показан, чтобы код был виден целиком.
 *
 * ВНИМАНИЕ про точность: Delay_Ms(1) — это 1 мс плюс время работы
 * led_advance() и прочего кода, поэтому фактический тик чуть больше
 * номинала и реальные частоты чуть ниже расчётных. Для точных периодов
 * нужен аппаратный таймер (SysTick/RTC) с частотой 1 кГц.
 *
 * =====================================================================
 *  СБОРКА
 * =====================================================================
 *
 *   pio run -e ch32v003-rates              # из корня репозитория
 *   pio run -t upload -e ch32v003-rates
 *
 * Собственных проектных файлов у примера нет: окружение ch32v003-rates
 * в корневом platformio.ini выбирает этот каталог через
 * build_src_filter, а библиотека подключается один раз через
 * lib_deps = symlink://. (копий led.h/led.c здесь нет).
 *
 * =====================================================================
 *  АППАРАТНАЯ КОНФИГУРАЦИЯ
 * =====================================================================
 *
 *   МК:     CH32V003F4P6 (RISC-V 48 МГц, 16 КБ Flash, 2 КБ RAM)
 *   Диоды:  PC4 (LED0), PC5 (LED1), PC6 (LED2), PC7 (LED3)
 *   Уровень: HIGH (любой level > 0 = «горит»)
 */

#include "led.h"
#include "ch32v00x.h"
#include "ch32v00x_gpio.h"
#include "ch32v00x_rcc.h"
#include "debug.h"        /* Delay_Init() / Delay_Ms() из WCH SDK */

/** Тик примера: 1 мс. */
#define TICK_MS 1u

/**
 * Периоды в тиках (при TICK_MS = 1 это ровно 4 с / 2 с / 1 с / 0.5 с).
 * Тик — единица пользователя: библиотека ни о каких миллисекундах
 * не знает, длительности везде в тиках.
 */
static const uint16_t period_ticks[4] = {
    4000u,   /* LED0: 1 раз в 4 с  */
    2000u,   /* LED1: 1 раз в 2 с  */
    1000u,   /* LED2: 1 раз в 1 с  */
     500u    /* LED3: 2 раза в 1 с  */
};

/** Запись уровня в вывод: обычный GPIO-включатель. */
static void led_hw_set(uint8_t id, uint8_t level)
{
    if (id >= LED_COUNT) {
        return;
    }
    if (level != 0u) {
        GPIO_SetBits(GPIOC, (uint16_t)(1UL << (4 + id)));
    } else {
        GPIO_ResetBits(GPIOC, (uint16_t)(1UL << (4 + id)));
    }
}

/** PC4–PC7 как push-pull выходы, начальный уровень LOW. */
static void gpio_init_leds(void)
{
    GPIO_InitTypeDef gpio = {0};

    RCC_APB2PeriphClockCmd(RCC_APB2Periph_GPIOC, ENABLE);

    gpio.GPIO_Pin   = GPIO_Pin_4 | GPIO_Pin_5 | GPIO_Pin_6 | GPIO_Pin_7;
    gpio.GPIO_Mode  = GPIO_Mode_Out_PP;
    gpio.GPIO_Speed = GPIO_Speed_2MHz;
    GPIO_Init(GPIOC, &gpio);

    GPIO_ResetBits(GPIOC, GPIO_Pin_4 | GPIO_Pin_5 | GPIO_Pin_6 | GPIO_Pin_7);
}

int main(void)
{
    uint8_t id;

    SystemCoreClockUpdate();
    Delay_Init();
    gpio_init_leds();

    led_init();
    led_set_callback(led_hw_set);

    /* Скважность 50 %: половина периода горит, половина гаснет.
     * led_blink() отменяет всё, что было на канале раньше. */
    for (id = 0; id < LED_COUNT; id++) {
        uint16_t half = (uint16_t)(period_ticks[id] / 2u);

        led_blink(id, half, half);
    }

    for (;;) {
        /* Единственное, что нужно для продвижения времени. */
        led_advance(TICK_MS);
        Delay_Ms(TICK_MS);
    }
}
